<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\examples\nn_cifar10_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\nn_gru_example.ewp</path>
    </project>
    <batchBuild />
</workspace>
