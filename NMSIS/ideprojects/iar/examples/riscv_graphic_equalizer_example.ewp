# IAR project riscv_graphic_equalizer_example.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: ..\..\..\DSP\Include\dsp; ..\..\..\NN\Include; ..\..\..\Core\Include; ..\..\..\DSP\Include; ..\..\..\DSP\PrivateInclude; ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Common\Include
  IASMRISCV.AsmIncludePath: ..\..\..\..\..\nuclei-sdk\NMSIS\Core\Include; ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Common\Include
  OBJCOPY.OOCOutputFile: BasicMathFunctions.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: riscv_graphic_equalizer_example.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Board\nuclei_fpga_eval\Source\IAR\iar_evalsoc_ilm.icf
  ILINK.IlinkAdditionalLibs: ..\library\prebuilt\libnmsis_dsp_rv32imafdc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../DSP/Examples/RISCV/riscv_graphic_equalizer_example/: math_helper.c math_helper.h riscv_graphic_equalizer_data.c riscv_graphic_equalizer_example_q31.c
  group nuclei_sdk/NMSIS/Core/Include
    ../../../../../nuclei-sdk/NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_plic.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/NMSIS/DSP/Include
    ../../../../../nuclei-sdk/NMSIS/DSP/Include/: riscv_common_tables.h riscv_common_tables_f16.h riscv_const_structs.h riscv_const_structs_f16.h riscv_helium_utils.h riscv_math.h riscv_math_f16.h riscv_math_memory.h riscv_math_types.h riscv_math_types_f16.h riscv_mve_tables.h riscv_mve_tables_f16.h riscv_vec_math.h riscv_vec_math_f16.h
  group nuclei_sdk/NMSIS/DSP/Include/dsp
    ../../../../../nuclei-sdk/NMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group nuclei_sdk/NMSIS/DSP/PrivateInclude
    ../../../../../nuclei-sdk/NMSIS/DSP/PrivateInclude/: riscv_sorting.h riscv_vec_fft.h riscv_vec_filtering.h
  group nuclei_sdk/NMSIS/NN/Include
    ../../../../../nuclei-sdk/NMSIS/NN/Include/: riscv_nn_math_types.h riscv_nn_tables.h riscv_nn_types.h riscv_nnfunctions.h riscv_nnsupportfunctions.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../../../nuclei-sdk/SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../../../nuclei-sdk/SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_ilm.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Include/: evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S intexc_evalsoc_s.S startup.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
