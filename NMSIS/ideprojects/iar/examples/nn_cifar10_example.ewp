# IAR project nn_cifar10_example.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: UX900 Nuclei UX900
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: ..\..\..\NN\Include; ..\..\..\Core\Include; ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Board\nuclei_fpga_eval\Include; ..\..\..\..\..\nuclei-sdk\SoC\evalsoc\Common\Include
  IASMRISCV.AsmIncludePath: ..\..\..\..\..\nuclei-sdk\NMSIS\Core\Include
  OBJCOPY.OOCOutputFile: nn_cifar10_example.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: nn_cifar10_example.out
  ILINK.IlinkIcfFile: ..\linker\iar_evalsoc_ilm_512K.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\nuclei-sdk\NMSIS\Library\NN\GCC\libnmsis_nn_rv64imafdc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group application
    ../../../NN/Examples/RISCV/cifar10/: bench.h image_data.h riscv_nnexamples_cifar10.c riscv_nnexamples_cifar10_inputs.h riscv_nnexamples_cifar10_parameter.h riscv_nnexamples_cifar10_weights.h
  group nuclei_sdk/NMSIS/Core/Include
    ../../../../../nuclei-sdk/NMSIS/Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group nuclei_sdk/NMSIS/NN/Include
    ../../../../../nuclei-sdk/NMSIS/NN/Include/: riscv_nn_math_types.h riscv_nn_tables.h riscv_nn_types.h riscv_nnfunctions.h riscv_nnsupportfunctions.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Include
    ../../../../../nuclei-sdk/SoC/evalsoc/Board/nuclei_fpga_eval/Include/: board_nuclei_fpga_eval.h nuclei_sdk_hal.h
  group nuclei_sdk/SoC/Board/nuclei_fpga_eval/Source/IAR
    ../../../../../nuclei-sdk/SoC/evalsoc/Board/nuclei_fpga_eval/Source/IAR/: iar_evalsoc_ilm.icf
  group nuclei_sdk/SoC/Common/Include
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Include/: evalsoc.h evalsoc_uart.h nuclei_sdk_soc.h system_evalsoc.h
  group nuclei_sdk/SoC/Common/Source
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/: evalsoc_common.c system_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Drivers
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/Drivers/: evalsoc_uart.c
  group nuclei_sdk/SoC/Common/Source/IAR
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/IAR/: intexc_evalsoc.S startup_evalsoc.c
  group nuclei_sdk/SoC/Common/Source/Stubs/iardlib
    ../../../../../nuclei-sdk/SoC/evalsoc/Common/Source/Stubs/iardlib/: stubs.c
