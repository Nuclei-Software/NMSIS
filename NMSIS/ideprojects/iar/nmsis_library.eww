<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\library\nmsis_dsp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\library\nmsis_nn.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\library\nmsis_nn_ref.ewp</path>
    </project>
    <batchBuild />
</workspace>
