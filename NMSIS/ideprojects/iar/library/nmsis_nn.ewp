# IAR project nmsis_nn.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCDefines: RISCV_MATH_LOOPUNROLL
  ICCRISCV.CCIncludePath2: ..\..\..\NN\Include; ..\..\..\Core\Include
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: nmsis_nn.out
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group Core/Include
    ../../../Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_plic.h core_feature_pma.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group NN/Include
    ../../../NN/Include/: riscv_nn_math_types.h riscv_nn_tables.h riscv_nn_types.h riscv_nnfunctions.h riscv_nnsupportfunctions.h
  group NN/Source/ActivationFunctions
    ../../../NN/Source/ActivationFunctions/: riscv_nn_activation_s16.c riscv_nn_activations_q15.c riscv_nn_activations_q7.c riscv_relu6_s8.c riscv_relu_q15.c riscv_relu_q7.c
  group NN/Source/BasicMathFunctions
    ../../../NN/Source/BasicMathFunctions/: riscv_elementwise_add_s16.c riscv_elementwise_add_s8.c riscv_elementwise_mul_acc_s16.c riscv_elementwise_mul_s16.c riscv_elementwise_mul_s16_batch_offset.c riscv_elementwise_mul_s16_s8.c riscv_elementwise_mul_s8.c riscv_maximum_s8.c riscv_minimum_s8.c
  group NN/Source/ConcatenationFunctions
    ../../../NN/Source/ConcatenationFunctions/: riscv_concatenation_s8_w.c riscv_concatenation_s8_x.c riscv_concatenation_s8_y.c riscv_concatenation_s8_z.c
  group NN/Source/ConvolutionFunctions
    ../../../NN/Source/ConvolutionFunctions/: riscv_convolve_1_x_n_s4.c riscv_convolve_1_x_n_s8.c riscv_convolve_1x1_HWC_q7_fast_nonsquare.c riscv_convolve_1x1_s4.c riscv_convolve_1x1_s4_fast.c riscv_convolve_1x1_s8.c riscv_convolve_1x1_s8_fast.c riscv_convolve_even_s4.c riscv_convolve_get_buffer_sizes_s16.c riscv_convolve_get_buffer_sizes_s4.c riscv_convolve_get_buffer_sizes_s8.c riscv_convolve_HWC_q15_basic.c riscv_convolve_HWC_q15_fast.c riscv_convolve_HWC_q15_fast_nonsquare.c riscv_convolve_HWC_q7_basic.c riscv_convolve_HWC_q7_basic_nonsquare.c riscv_convolve_HWC_q7_fast.c riscv_convolve_HWC_q7_fast_nonsquare.c riscv_convolve_HWC_q7_RGB.c riscv_convolve_s16.c riscv_convolve_s4.c riscv_convolve_s8.c riscv_convolve_wrapper_s16.c riscv_convolve_wrapper_s4.c riscv_convolve_wrapper_s8.c riscv_depthwise_conv_3x3_s8.c riscv_depthwise_conv_fast_s16.c riscv_depthwise_conv_get_buffer_sizes_s16.c riscv_depthwise_conv_get_buffer_sizes_s4.c riscv_depthwise_conv_get_buffer_sizes_s8.c riscv_depthwise_conv_s16.c riscv_depthwise_conv_s4.c riscv_depthwise_conv_s4_opt.c riscv_depthwise_conv_s8.c riscv_depthwise_conv_s8_opt.c riscv_depthwise_conv_wrapper_s16.c riscv_depthwise_conv_wrapper_s4.c riscv_depthwise_conv_wrapper_s8.c riscv_depthwise_separable_conv_HWC_q7.c riscv_depthwise_separable_conv_HWC_q7_nonsquare.c riscv_nn_depthwise_conv_s8_core.c riscv_nn_mat_mult_kernel_q7.c riscv_nn_mat_mult_kernel_q7_q15.c riscv_nn_mat_mult_kernel_q7_q15_reordered.c riscv_nn_mat_mult_kernel_q7_reordered.c riscv_nn_mat_mult_kernel_row_offset_s8_s16.c riscv_nn_mat_mult_kernel_s16.c riscv_nn_mat_mult_kernel_s4_s16.c riscv_nn_mat_mult_kernel_s8_s16.c riscv_nn_mat_mult_s8.c riscv_transpose_conv_get_buffer_sizes_s8.c riscv_transpose_conv_s8.c riscv_transpose_conv_wrapper_s8.c
  group NN/Source/FullyConnectedFunctions
    ../../../NN/Source/FullyConnectedFunctions/: riscv_batch_matmul_s16.c riscv_batch_matmul_s8.c riscv_fully_connected_get_buffer_sizes_s16.c riscv_fully_connected_get_buffer_sizes_s8.c riscv_fully_connected_mat_q7_vec_q15.c riscv_fully_connected_mat_q7_vec_q15_opt.c riscv_fully_connected_per_channel_s8.c riscv_fully_connected_q15.c riscv_fully_connected_q15_opt.c riscv_fully_connected_q7.c riscv_fully_connected_q7_opt.c riscv_fully_connected_s16.c riscv_fully_connected_s4.c riscv_fully_connected_s8.c riscv_fully_connected_wrapper_s8.c riscv_vector_sum_s8.c riscv_vector_sum_s8_s64.c
  group NN/Source/LSTMFunctions
    ../../../NN/Source/LSTMFunctions/: riscv_lstm_unidirectional_s16.c riscv_lstm_unidirectional_s8.c
  group NN/Source/NNSupportFunctions
    ../../../NN/Source/NNSupportFunctions/: riscv_nn_accumulate_q7_to_q15.c riscv_nn_add_q7.c riscv_nn_copy_q15.c riscv_nn_copy_q7.c riscv_nn_depthwise_conv_nt_t_padded_s8.c riscv_nn_depthwise_conv_nt_t_s16.c riscv_nn_depthwise_conv_nt_t_s4.c riscv_nn_depthwise_conv_nt_t_s8.c riscv_nn_fill_q15.c riscv_nn_fill_q7.c riscv_nn_lstm_calculate_gate_s16.c riscv_nn_lstm_calculate_gate_s8_s16.c riscv_nn_lstm_step_s16.c riscv_nn_lstm_step_s8.c riscv_nn_mat_mul_core_1x_s4.c riscv_nn_mat_mul_core_1x_s8.c riscv_nn_mat_mul_core_4x_s8.c riscv_nn_mat_mult_nt_interleaved_t_even_s4.c riscv_nn_mat_mult_nt_t_s16.c riscv_nn_mat_mult_nt_t_s4.c riscv_nn_mat_mult_nt_t_s8.c riscv_nn_mat_mult_nt_t_s8_s32.c riscv_nn_mult_q15.c riscv_nn_mult_q7.c riscv_nn_transpose_conv_row_s8_s32.c riscv_nn_vec_mat_mul_result_acc_s16.c riscv_nn_vec_mat_mul_result_acc_s8_s16.c riscv_nn_vec_mat_mult_t_per_ch_s8.c riscv_nn_vec_mat_mult_t_s16.c riscv_nn_vec_mat_mult_t_s16_s16.c riscv_nn_vec_mat_mult_t_s4.c riscv_nn_vec_mat_mult_t_s8.c riscv_nn_vec_mat_mult_t_svdf_s8.c riscv_nntables.c riscv_q7_to_q15_no_shift.c riscv_q7_to_q15_reordered_no_shift.c riscv_q7_to_q15_reordered_with_offset.c riscv_q7_to_q15_with_offset.c riscv_q7_to_q7_no_shift.c riscv_q7_to_q7_reordered_no_shift.c riscv_s8_to_s16_unordered_with_offset.c
  group NN/Source/PadFunctions
    ../../../NN/Source/PadFunctions/: riscv_pad_s8.c
  group NN/Source/PoolingFunctions
    ../../../NN/Source/PoolingFunctions/: riscv_avgpool_get_buffer_sizes_s16.c riscv_avgpool_get_buffer_sizes_s8.c riscv_avgpool_s16.c riscv_avgpool_s8.c riscv_max_pool_s16.c riscv_max_pool_s8.c riscv_pool_q7_HWC.c
  group NN/Source/ReshapeFunctions
    ../../../NN/Source/ReshapeFunctions/: riscv_reshape_s8.c
  group NN/Source/SoftmaxFunctions
    ../../../NN/Source/SoftmaxFunctions/: riscv_nn_softmax_common_s8.c riscv_softmax_q15.c riscv_softmax_q7.c riscv_softmax_s16.c riscv_softmax_s8.c riscv_softmax_s8_s16.c riscv_softmax_u8.c riscv_softmax_with_batch_q7.c
  group NN/Source/SVDFunctions
    ../../../NN/Source/SVDFunctions/: riscv_svdf_get_buffer_sizes_s8.c riscv_svdf_s8.c riscv_svdf_state_s16_s8.c
  group NN/Source/TransposeFunctions
    ../../../NN/Source/TransposeFunctions/: riscv_transpose_s8.c
