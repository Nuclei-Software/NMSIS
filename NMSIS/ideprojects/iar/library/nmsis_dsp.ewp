# IAR project nmsis_dsp.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCDefines: RISCV_MATH_LOOPUNROLL; RISCV_DSP_ATTRIBUTE=__attribute__((weak))
  ICCRISCV.CCIncludePath2: ..\..\..\Core\Include; ..\..\..\DSP\Include; ..\..\..\DSP\PrivateInclude
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: nmsis_dsp.out
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group Core/Include
    ../../../Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_plic.h core_feature_pma.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group DSP/Include
    ../../../DSP/Include/: riscv_common_tables.h riscv_common_tables_f16.h riscv_const_structs.h riscv_const_structs_f16.h riscv_helium_utils.h riscv_math.h riscv_math_f16.h riscv_math_memory.h riscv_math_types.h riscv_math_types_f16.h riscv_mve_tables.h riscv_mve_tables_f16.h riscv_vec_math.h riscv_vec_math_f16.h
  group DSP/Include/dsp
    ../../../DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group DSP/PrivateInclude
    ../../../DSP/PrivateInclude/: riscv_sorting.h riscv_vec_fft.h riscv_vec_filtering.h
  group DSP/Source/BasicMathFunctions
    ../../../DSP/Source/BasicMathFunctions/: riscv_abs_f16.c riscv_abs_f32.c riscv_abs_f64.c riscv_abs_q15.c riscv_abs_q31.c riscv_abs_q7.c riscv_add_f16.c riscv_add_f32.c riscv_add_f64.c riscv_add_q15.c riscv_add_q31.c riscv_add_q7.c riscv_and_u16.c riscv_and_u32.c riscv_and_u8.c riscv_clip_f16.c riscv_clip_f32.c riscv_clip_q15.c riscv_clip_q31.c riscv_clip_q7.c riscv_dot_prod_f16.c riscv_dot_prod_f32.c riscv_dot_prod_f64.c riscv_dot_prod_q15.c riscv_dot_prod_q31.c riscv_dot_prod_q7.c riscv_mult_f16.c riscv_mult_f32.c riscv_mult_f64.c riscv_mult_q15.c riscv_mult_q31.c riscv_mult_q7.c riscv_negate_f16.c riscv_negate_f32.c riscv_negate_f64.c riscv_negate_q15.c riscv_negate_q31.c riscv_negate_q7.c riscv_not_u16.c riscv_not_u32.c riscv_not_u8.c riscv_offset_f16.c riscv_offset_f32.c riscv_offset_f64.c riscv_offset_q15.c riscv_offset_q31.c riscv_offset_q7.c riscv_or_u16.c riscv_or_u32.c riscv_or_u8.c riscv_scale_f16.c riscv_scale_f32.c riscv_scale_f64.c riscv_scale_q15.c riscv_scale_q31.c riscv_scale_q7.c riscv_shift_q15.c riscv_shift_q31.c riscv_shift_q7.c riscv_sub_f16.c riscv_sub_f32.c riscv_sub_f64.c riscv_sub_q15.c riscv_sub_q31.c riscv_sub_q7.c riscv_xor_u16.c riscv_xor_u32.c riscv_xor_u8.c
  group DSP/Source/BayesFunctions
    ../../../DSP/Source/BayesFunctions/: riscv_gaussian_naive_bayes_predict_f16.c riscv_gaussian_naive_bayes_predict_f32.c
  group DSP/Source/CommonTables
    ../../../DSP/Source/CommonTables/: riscv_common_tables.c riscv_common_tables_f16.c riscv_const_structs.c riscv_const_structs_f16.c riscv_mve_tables.c riscv_mve_tables_f16.c
  group DSP/Source/ComplexMathFunctions
    ../../../DSP/Source/ComplexMathFunctions/: riscv_cmplx_conj_f16.c riscv_cmplx_conj_f32.c riscv_cmplx_conj_q15.c riscv_cmplx_conj_q31.c riscv_cmplx_dot_prod_f16.c riscv_cmplx_dot_prod_f32.c riscv_cmplx_dot_prod_q15.c riscv_cmplx_dot_prod_q31.c riscv_cmplx_mag_f16.c riscv_cmplx_mag_f32.c riscv_cmplx_mag_f64.c riscv_cmplx_mag_fast_q15.c riscv_cmplx_mag_q15.c riscv_cmplx_mag_q31.c riscv_cmplx_mag_squared_f16.c riscv_cmplx_mag_squared_f32.c riscv_cmplx_mag_squared_f64.c riscv_cmplx_mag_squared_q15.c riscv_cmplx_mag_squared_q31.c riscv_cmplx_mult_cmplx_f16.c riscv_cmplx_mult_cmplx_f32.c riscv_cmplx_mult_cmplx_f64.c riscv_cmplx_mult_cmplx_q15.c riscv_cmplx_mult_cmplx_q31.c riscv_cmplx_mult_real_f16.c riscv_cmplx_mult_real_f32.c riscv_cmplx_mult_real_q15.c riscv_cmplx_mult_real_q31.c
  group DSP/Source/ControllerFunctions
    ../../../DSP/Source/ControllerFunctions/: riscv_pid_init_f32.c riscv_pid_init_q15.c riscv_pid_init_q31.c riscv_pid_reset_f32.c riscv_pid_reset_q15.c riscv_pid_reset_q31.c riscv_sin_cos_f32.c riscv_sin_cos_q31.c
  group DSP/Source/DistanceFunctions
    ../../../DSP/Source/DistanceFunctions/: riscv_boolean_distance.c riscv_boolean_distance_template.h riscv_braycurtis_distance_f16.c riscv_braycurtis_distance_f32.c riscv_canberra_distance_f16.c riscv_canberra_distance_f32.c riscv_chebyshev_distance_f16.c riscv_chebyshev_distance_f32.c riscv_chebyshev_distance_f64.c riscv_cityblock_distance_f16.c riscv_cityblock_distance_f32.c riscv_cityblock_distance_f64.c riscv_correlation_distance_f16.c riscv_correlation_distance_f32.c riscv_cosine_distance_f16.c riscv_cosine_distance_f32.c riscv_cosine_distance_f64.c riscv_dice_distance.c riscv_dtw_distance_f32.c riscv_dtw_init_window_q7.c riscv_dtw_path_f32.c riscv_euclidean_distance_f16.c riscv_euclidean_distance_f32.c riscv_euclidean_distance_f64.c riscv_hamming_distance.c riscv_jaccard_distance.c riscv_jensenshannon_distance_f16.c riscv_jensenshannon_distance_f32.c riscv_kulsinski_distance.c riscv_minkowski_distance_f16.c riscv_minkowski_distance_f32.c riscv_rogerstanimoto_distance.c riscv_russellrao_distance.c riscv_sokalmichener_distance.c riscv_sokalsneath_distance.c riscv_yule_distance.c
  group DSP/Source/FastMathFunctions
    ../../../DSP/Source/FastMathFunctions/: riscv_atan2_f16.c riscv_atan2_f32.c riscv_atan2_q15.c riscv_atan2_q31.c riscv_cos_f32.c riscv_cos_q15.c riscv_cos_q31.c riscv_divide_q15.c riscv_divide_q31.c riscv_sin_f32.c riscv_sin_q15.c riscv_sin_q31.c riscv_sqrt_q15.c riscv_sqrt_q31.c riscv_vexp_f16.c riscv_vexp_f32.c riscv_vexp_f64.c riscv_vinverse_f16.c riscv_vlog_f16.c riscv_vlog_f32.c riscv_vlog_f64.c riscv_vlog_q15.c riscv_vlog_q31.c
  group DSP/Source/FilteringFunctions
    ../../../DSP/Source/FilteringFunctions/: riscv_biquad_cascade_df1_32x64_init_q31.c riscv_biquad_cascade_df1_32x64_q31.c riscv_biquad_cascade_df1_f16.c riscv_biquad_cascade_df1_f32.c riscv_biquad_cascade_df1_fast_q15.c riscv_biquad_cascade_df1_fast_q31.c riscv_biquad_cascade_df1_init_f16.c riscv_biquad_cascade_df1_init_f32.c riscv_biquad_cascade_df1_init_q15.c riscv_biquad_cascade_df1_init_q31.c riscv_biquad_cascade_df1_q15.c riscv_biquad_cascade_df1_q31.c riscv_biquad_cascade_df2T_f16.c riscv_biquad_cascade_df2T_f32.c riscv_biquad_cascade_df2T_f64.c riscv_biquad_cascade_df2T_init_f16.c riscv_biquad_cascade_df2T_init_f32.c riscv_biquad_cascade_df2T_init_f64.c riscv_biquad_cascade_stereo_df2T_f16.c riscv_biquad_cascade_stereo_df2T_f32.c riscv_biquad_cascade_stereo_df2T_init_f16.c riscv_biquad_cascade_stereo_df2T_init_f32.c riscv_conv_f32.c riscv_conv_fast_opt_q15.c riscv_conv_fast_q15.c riscv_conv_fast_q31.c riscv_conv_opt_q15.c riscv_conv_opt_q7.c riscv_conv_partial_f32.c riscv_conv_partial_fast_opt_q15.c riscv_conv_partial_fast_q15.c riscv_conv_partial_fast_q31.c riscv_conv_partial_opt_q15.c riscv_conv_partial_opt_q7.c riscv_conv_partial_q15.c riscv_conv_partial_q31.c riscv_conv_partial_q7.c riscv_conv_q15.c riscv_conv_q31.c riscv_conv_q7.c riscv_correlate_f16.c riscv_correlate_f32.c riscv_correlate_f64.c riscv_correlate_fast_opt_q15.c riscv_correlate_fast_q15.c riscv_correlate_fast_q31.c riscv_correlate_opt_q15.c riscv_correlate_opt_q7.c riscv_correlate_q15.c riscv_correlate_q31.c riscv_correlate_q7.c riscv_fir_decimate_f32.c riscv_fir_decimate_f64.c riscv_fir_decimate_fast_q15.c riscv_fir_decimate_fast_q31.c riscv_fir_decimate_init_f32.c riscv_fir_decimate_init_f64.c riscv_fir_decimate_init_q15.c riscv_fir_decimate_init_q31.c riscv_fir_decimate_q15.c riscv_fir_decimate_q31.c riscv_fir_f16.c riscv_fir_f32.c riscv_fir_f64.c riscv_fir_fast_q15.c riscv_fir_fast_q31.c riscv_fir_init_f16.c riscv_fir_init_f32.c riscv_fir_init_f64.c riscv_fir_init_q15.c riscv_fir_init_q31.c riscv_fir_init_q7.c riscv_fir_interpolate_f32.c riscv_fir_interpolate_init_f32.c riscv_fir_interpolate_init_q15.c riscv_fir_interpolate_init_q31.c riscv_fir_interpolate_q15.c riscv_fir_interpolate_q31.c riscv_fir_lattice_f32.c riscv_fir_lattice_init_f32.c riscv_fir_lattice_init_q15.c riscv_fir_lattice_init_q31.c riscv_fir_lattice_q15.c riscv_fir_lattice_q31.c riscv_fir_q15.c riscv_fir_q31.c riscv_fir_q7.c riscv_fir_sparse_f32.c riscv_fir_sparse_init_f32.c riscv_fir_sparse_init_q15.c riscv_fir_sparse_init_q31.c riscv_fir_sparse_init_q7.c riscv_fir_sparse_q15.c riscv_fir_sparse_q31.c riscv_fir_sparse_q7.c riscv_iir_lattice_f32.c riscv_iir_lattice_init_f32.c riscv_iir_lattice_init_q15.c riscv_iir_lattice_init_q31.c riscv_iir_lattice_q15.c riscv_iir_lattice_q31.c riscv_levinson_durbin_f16.c riscv_levinson_durbin_f32.c riscv_levinson_durbin_q31.c riscv_lms_f32.c riscv_lms_init_f32.c riscv_lms_init_q15.c riscv_lms_init_q31.c riscv_lms_norm_f32.c riscv_lms_norm_init_f32.c riscv_lms_norm_init_q15.c riscv_lms_norm_init_q31.c riscv_lms_norm_q15.c riscv_lms_norm_q31.c riscv_lms_q15.c riscv_lms_q31.c
  group DSP/Source/InterpolationFunctions
    ../../../DSP/Source/InterpolationFunctions/: riscv_bilinear_interp_f16.c riscv_bilinear_interp_f32.c riscv_bilinear_interp_q15.c riscv_bilinear_interp_q31.c riscv_bilinear_interp_q7.c riscv_linear_interp_f16.c riscv_linear_interp_f32.c riscv_linear_interp_q15.c riscv_linear_interp_q31.c riscv_linear_interp_q7.c riscv_spline_interp_f32.c riscv_spline_interp_init_f32.c
  group DSP/Source/MatrixFunctions
    ../../../DSP/Source/MatrixFunctions/: riscv_householder_f16.c riscv_householder_f32.c riscv_householder_f64.c riscv_mat_add_f16.c riscv_mat_add_f32.c riscv_mat_add_q15.c riscv_mat_add_q31.c riscv_mat_cholesky_f16.c riscv_mat_cholesky_f32.c riscv_mat_cholesky_f64.c riscv_mat_cmplx_mult_f16.c riscv_mat_cmplx_mult_f32.c riscv_mat_cmplx_mult_q15.c riscv_mat_cmplx_mult_q31.c riscv_mat_cmplx_trans_f16.c riscv_mat_cmplx_trans_f32.c riscv_mat_cmplx_trans_q15.c riscv_mat_cmplx_trans_q31.c riscv_mat_init_f16.c riscv_mat_init_f32.c riscv_mat_init_f64.c riscv_mat_init_q15.c riscv_mat_init_q31.c riscv_mat_init_q7.c riscv_mat_inverse_f16.c riscv_mat_inverse_f32.c riscv_mat_inverse_f64.c riscv_mat_ldlt_f32.c riscv_mat_ldlt_f64.c riscv_mat_mult_f16.c riscv_mat_mult_f32.c riscv_mat_mult_f64.c riscv_mat_mult_fast_q15.c riscv_mat_mult_fast_q31.c riscv_mat_mult_opt_q31.c riscv_mat_mult_q15.c riscv_mat_mult_q31.c riscv_mat_mult_q7.c riscv_mat_qr_f16.c riscv_mat_qr_f32.c riscv_mat_qr_f64.c riscv_mat_scale_f16.c riscv_mat_scale_f32.c riscv_mat_scale_q15.c riscv_mat_scale_q31.c riscv_mat_solve_lower_triangular_f16.c riscv_mat_solve_lower_triangular_f32.c riscv_mat_solve_lower_triangular_f64.c riscv_mat_solve_upper_triangular_f16.c riscv_mat_solve_upper_triangular_f32.c riscv_mat_solve_upper_triangular_f64.c riscv_mat_sub_f16.c riscv_mat_sub_f32.c riscv_mat_sub_f64.c riscv_mat_sub_q15.c riscv_mat_sub_q31.c riscv_mat_trans_f16.c riscv_mat_trans_f32.c riscv_mat_trans_f64.c riscv_mat_trans_q15.c riscv_mat_trans_q31.c riscv_mat_trans_q7.c riscv_mat_vec_mult_f16.c riscv_mat_vec_mult_f32.c riscv_mat_vec_mult_q15.c riscv_mat_vec_mult_q31.c riscv_mat_vec_mult_q7.c
  group DSP/Source/QuaternionMathFunctions
    ../../../DSP/Source/QuaternionMathFunctions/: riscv_quaternion2rotation_f32.c riscv_quaternion_conjugate_f32.c riscv_quaternion_inverse_f32.c riscv_quaternion_norm_f32.c riscv_quaternion_normalize_f32.c riscv_quaternion_product_f32.c riscv_quaternion_product_single_f32.c riscv_rotation2quaternion_f32.c
  group DSP/Source/StatisticsFunctions
    ../../../DSP/Source/StatisticsFunctions/: riscv_absmax_f16.c riscv_absmax_f32.c riscv_absmax_f64.c riscv_absmax_no_idx_f16.c riscv_absmax_no_idx_f32.c riscv_absmax_no_idx_f64.c riscv_absmax_no_idx_q15.c riscv_absmax_no_idx_q31.c riscv_absmax_no_idx_q7.c riscv_absmax_q15.c riscv_absmax_q31.c riscv_absmax_q7.c riscv_absmin_f16.c riscv_absmin_f32.c riscv_absmin_f64.c riscv_absmin_no_idx_f16.c riscv_absmin_no_idx_f32.c riscv_absmin_no_idx_f64.c riscv_absmin_no_idx_q15.c riscv_absmin_no_idx_q31.c riscv_absmin_no_idx_q7.c riscv_absmin_q15.c riscv_absmin_q31.c riscv_absmin_q7.c riscv_accumulate_f16.c riscv_accumulate_f32.c riscv_accumulate_f64.c riscv_entropy_f16.c riscv_entropy_f32.c riscv_entropy_f64.c riscv_kullback_leibler_f16.c riscv_kullback_leibler_f32.c riscv_kullback_leibler_f64.c riscv_logsumexp_dot_prod_f16.c riscv_logsumexp_dot_prod_f32.c riscv_logsumexp_f16.c riscv_logsumexp_f32.c riscv_max_f16.c riscv_max_f32.c riscv_max_f64.c riscv_max_no_idx_f16.c riscv_max_no_idx_f32.c riscv_max_no_idx_f64.c riscv_max_no_idx_q15.c riscv_max_no_idx_q31.c riscv_max_no_idx_q7.c riscv_max_q15.c riscv_max_q31.c riscv_max_q7.c riscv_mean_f16.c riscv_mean_f32.c riscv_mean_f64.c riscv_mean_q15.c riscv_mean_q31.c riscv_mean_q7.c riscv_min_f16.c riscv_min_f32.c riscv_min_f64.c riscv_min_no_idx_f16.c riscv_min_no_idx_f32.c riscv_min_no_idx_f64.c riscv_min_no_idx_q15.c riscv_min_no_idx_q31.c riscv_min_no_idx_q7.c riscv_min_q15.c riscv_min_q31.c riscv_min_q7.c riscv_mse_f16.c riscv_mse_f32.c riscv_mse_f64.c riscv_mse_q15.c riscv_mse_q31.c riscv_mse_q7.c riscv_power_f16.c riscv_power_f32.c riscv_power_f64.c riscv_power_q15.c riscv_power_q31.c riscv_power_q7.c riscv_rms_f16.c riscv_rms_f32.c riscv_rms_q15.c riscv_rms_q31.c riscv_std_f16.c riscv_std_f32.c riscv_std_f64.c riscv_std_q15.c riscv_std_q31.c riscv_var_f16.c riscv_var_f32.c riscv_var_f64.c riscv_var_q15.c riscv_var_q31.c
  group DSP/Source/SupportFunctions
    ../../../DSP/Source/SupportFunctions/: riscv_barycenter_f16.c riscv_barycenter_f32.c riscv_bitonic_sort_f32.c riscv_bubble_sort_f32.c riscv_copy_f16.c riscv_copy_f32.c riscv_copy_f64.c riscv_copy_q15.c riscv_copy_q31.c riscv_copy_q7.c riscv_f16_to_f64.c riscv_f16_to_float.c riscv_f16_to_q15.c riscv_f64_to_f16.c riscv_f64_to_float.c riscv_f64_to_q15.c riscv_f64_to_q31.c riscv_f64_to_q7.c riscv_fill_f16.c riscv_fill_f32.c riscv_fill_f64.c riscv_fill_q15.c riscv_fill_q31.c riscv_fill_q7.c riscv_float_to_f16.c riscv_float_to_f64.c riscv_float_to_q15.c riscv_float_to_q31.c riscv_float_to_q7.c riscv_heap_sort_f32.c riscv_insertion_sort_f32.c riscv_merge_sort_f32.c riscv_merge_sort_init_f32.c riscv_q15_to_f16.c riscv_q15_to_f64.c riscv_q15_to_float.c riscv_q15_to_q31.c riscv_q15_to_q7.c riscv_q31_to_f64.c riscv_q31_to_float.c riscv_q31_to_q15.c riscv_q31_to_q7.c riscv_q7_to_f64.c riscv_q7_to_float.c riscv_q7_to_q15.c riscv_q7_to_q31.c riscv_quick_sort_f32.c riscv_selection_sort_f32.c riscv_sort_f32.c riscv_sort_init_f32.c riscv_weighted_average_f16.c riscv_weighted_average_f32.c
  group DSP/Source/SVMFunctions
    ../../../DSP/Source/SVMFunctions/: riscv_svm_linear_init_f16.c riscv_svm_linear_init_f32.c riscv_svm_linear_predict_f16.c riscv_svm_linear_predict_f32.c riscv_svm_polynomial_init_f16.c riscv_svm_polynomial_init_f32.c riscv_svm_polynomial_predict_f16.c riscv_svm_polynomial_predict_f32.c riscv_svm_rbf_init_f16.c riscv_svm_rbf_init_f32.c riscv_svm_rbf_predict_f16.c riscv_svm_rbf_predict_f32.c riscv_svm_sigmoid_init_f16.c riscv_svm_sigmoid_init_f32.c riscv_svm_sigmoid_predict_f16.c riscv_svm_sigmoid_predict_f32.c
  group DSP/Source/TransformFunctions
    ../../../DSP/Source/TransformFunctions/: riscv_bitreversal.c riscv_bitreversal2.c riscv_bitreversal_f16.c riscv_cfft_f16.c riscv_cfft_f32.c riscv_cfft_f64.c riscv_cfft_init_f16.c riscv_cfft_init_f32.c riscv_cfft_init_f64.c riscv_cfft_init_q15.c riscv_cfft_init_q31.c riscv_cfft_q15.c riscv_cfft_q31.c riscv_cfft_radix2_f16.c riscv_cfft_radix2_f32.c riscv_cfft_radix2_init_f16.c riscv_cfft_radix2_init_f32.c riscv_cfft_radix2_init_q15.c riscv_cfft_radix2_init_q31.c riscv_cfft_radix2_q15.c riscv_cfft_radix2_q31.c riscv_cfft_radix4_f16.c riscv_cfft_radix4_f32.c riscv_cfft_radix4_init_f16.c riscv_cfft_radix4_init_f32.c riscv_cfft_radix4_init_q15.c riscv_cfft_radix4_init_q31.c riscv_cfft_radix4_q15.c riscv_cfft_radix4_q31.c riscv_cfft_radix8_f16.c riscv_cfft_radix8_f32.c riscv_dct4_f32.c riscv_dct4_init_f32.c riscv_dct4_init_q15.c riscv_dct4_init_q31.c riscv_dct4_q15.c riscv_dct4_q31.c riscv_mfcc_f16.c riscv_mfcc_f32.c riscv_mfcc_init_f16.c riscv_mfcc_init_f32.c riscv_mfcc_init_q15.c riscv_mfcc_init_q31.c riscv_mfcc_q15.c riscv_mfcc_q31.c riscv_rfft_f32.c riscv_rfft_fast_f16.c riscv_rfft_fast_f32.c riscv_rfft_fast_f64.c riscv_rfft_fast_init_f16.c riscv_rfft_fast_init_f32.c riscv_rfft_fast_init_f64.c riscv_rfft_init_f32.c riscv_rfft_init_q15.c riscv_rfft_init_q31.c riscv_rfft_q15.c riscv_rfft_q31.c
  group DSP/Source/WindowFunctions
    ../../../DSP/Source/WindowFunctions/: riscv_bartlett_f32.c riscv_bartlett_f64.c riscv_blackman_harris_92db_f32.c riscv_blackman_harris_92db_f64.c riscv_hamming_f32.c riscv_hamming_f64.c riscv_hanning_f32.c riscv_hanning_f64.c riscv_hft116d_f32.c riscv_hft116d_f64.c riscv_hft144d_f32.c riscv_hft144d_f64.c riscv_hft169d_f32.c riscv_hft169d_f64.c riscv_hft196d_f32.c riscv_hft196d_f64.c riscv_hft223d_f32.c riscv_hft223d_f64.c riscv_hft248d_f32.c riscv_hft248d_f64.c riscv_hft90d_f32.c riscv_hft90d_f64.c riscv_hft95_f32.c riscv_hft95_f64.c riscv_nuttall3_f32.c riscv_nuttall3_f64.c riscv_nuttall3a_f32.c riscv_nuttall3a_f64.c riscv_nuttall3b_f32.c riscv_nuttall3b_f64.c riscv_nuttall4_f32.c riscv_nuttall4_f64.c riscv_nuttall4a_f32.c riscv_nuttall4a_f64.c riscv_nuttall4b_f32.c riscv_nuttall4b_f64.c riscv_nuttall4c_f32.c riscv_nuttall4c_f64.c riscv_welch_f32.c riscv_welch_f64.c
