# IAR project nmsis_nn_ref.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: N300 Nuclei N300
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: ..\..\..\NN\Include; ..\..\..\Core\Include; ..\..\..\NN\Tests\Ref\Source
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: nmsis_nn_full.out
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group Core/Include
    ../../../Core/Include/: core_compatiable.h core_feature_base.h core_feature_bitmanip.h core_feature_cache.h core_feature_cidu.h core_feature_dsp.h core_feature_eclic.h core_feature_fpu.h core_feature_pmp.h core_feature_spmp.h core_feature_timer.h core_feature_vector.h nmsis_bench.h nmsis_compiler.h nmsis_core.h nmsis_gcc.h nmsis_iar.h nmsis_version.h riscv_bits.h riscv_encoding.h
  group NN/Include
    ../../../NN/Include/: riscv_nn_math_types.h riscv_nn_tables.h riscv_nn_types.h riscv_nnfunctions.h riscv_nnsupportfunctions.h
  group NN/Source
    ../../../NN/Tests/Ref/Source/: fully_connected_testing_weights.h ref_functions.h
  group NN/Source/ActivationFunctions
    ../../../NN/Tests/Ref/Source/ActivationFunctions/: riscv_nn_activations_q15_ref.c riscv_nn_activations_q7_ref.c riscv_relu6_s8_ref.c riscv_relu_q15_ref.c riscv_relu_q7_ref.c
  group NN/Source/BasicMathFunctions
    ../../../NN/Tests/Ref/Source/BasicMathFunctions/: riscv_elementwise_add_s8_ref.c riscv_elementwise_mul_s8_ref.c
  group NN/Source/ConcatenationFunctions
    ../../../NN/Tests/Ref/Source/ConcatenationFunctions/: riscv_concatenation_s8_w_ref.c riscv_concatenation_s8_x_ref.c riscv_concatenation_s8_y_ref.c riscv_concatenation_s8_z_ref.c
  group NN/Source/ConvolutionFunctions
    ../../../NN/Tests/Ref/Source/ConvolutionFunctions/: riscv_convolve_1_x_n_s8_ref.c riscv_convolve_1x1_HWC_q7_fast_nonsquare_ref.c riscv_convolve_1x1_s8_fast_ref.c riscv_convolve_get_buffer_sizes_s8_ref.c riscv_convolve_HWC_q15_basic_ref.c riscv_convolve_HWC_q15_fast_nonsquare_ref.c riscv_convolve_HWC_q15_fast_ref.c riscv_convolve_HWC_q15_ref.c riscv_convolve_HWC_q15_ref_nonsquare.c riscv_convolve_HWC_q7_basic_nonsquare_ref.c riscv_convolve_HWC_q7_basic_ref.c riscv_convolve_HWC_q7_fast_nonsquare_ref.c riscv_convolve_HWC_q7_fast_ref.c riscv_convolve_HWC_q7_ref.c riscv_convolve_HWC_q7_ref_nonsquare.c riscv_convolve_HWC_q7_RGB_ref.c riscv_convolve_s8_ref.c riscv_depthwise_conv_3x3_s8_ref.c riscv_depthwise_conv_get_buffer_sizes_s8_ref.c riscv_depthwise_conv_s8_opt_ref.c riscv_depthwise_conv_s8_ref.c riscv_depthwise_conv_u8_basic_ver1_ref.c riscv_depthwise_conv_wrapper_s8_ref.c riscv_depthwise_separable_conv_HWC_q7_nonsquare_ref.c riscv_depthwise_separable_conv_HWC_q7_ref.c riscv_depthwise_separable_conv_HWC_q7_ref_nonsquare.c riscv_nn_depthwise_conv_s8_core_ref.c riscv_nn_mat_mult_kernel_q7_q15_ref.c riscv_nn_mat_mult_kernel_q7_q15_reordered_ref.c riscv_nn_mat_mult_kernel_q7_reordered_ref.c riscv_nn_mat_mult_kernel_s8_s16_ref.c riscv_nn_mat_mult_kernel_s8_s16_reordered_ref.c riscv_nn_mat_mult_s8_ref.c
  group NN/Source/FullyConnectedFunctions
    ../../../NN/Tests/Ref/Source/FullyConnectedFunctions/: riscv_fully_connected_mat_q7_vec_q15_opt_ref.c riscv_fully_connected_mat_q7_vec_q15_ref.c riscv_fully_connected_q15_opt_ref.c riscv_fully_connected_q15_ref.c riscv_fully_connected_q7_opt_ref.c riscv_fully_connected_q7_ref.c riscv_fully_connected_s8_ref.c
  group NN/Source/NNSupportFunctions
    ../../../NN/Tests/Ref/Source/NNSupportFunctions/: riscv_nn_accumulate_q7_to_q15_ref.c riscv_nn_add_q7_ref.c riscv_nn_depthwise_conv_nt_t_padded_s8_ref.c riscv_nn_depthwise_conv_nt_t_s8_ref.c riscv_nn_mat_mul_core_1x_s8_ref.c riscv_nn_mat_mul_core_4x_s8_ref.c riscv_nn_mat_mult_nt_t_s8_ref.c riscv_nn_mult_q15_ref.c riscv_nn_mult_q7_ref.c riscv_nn_vec_mat_mult_t_s8_ref.c riscv_nn_vec_mat_mult_t_svdf_s8_ref.c riscv_q7_to_q15_no_shift_ref.c riscv_q7_to_q15_reordered_no_shift_ref.c riscv_q7_to_q15_reordered_with_offset_ref.c riscv_q7_to_q15_with_offset_ref.c riscv_q7_to_q7_no_shift_ref.c riscv_q7_to_q7_reordered_no_shift_ref.c
  group NN/Source/PoolingFunctions
    ../../../NN/Tests/Ref/Source/PoolingFunctions/: riscv_avgpool_s8_ref.c riscv_max_pool_s8_ref.c riscv_pool_q7_HWC_ref.c
  group NN/Source/ReshapeFunctions
    ../../../NN/Tests/Ref/Source/ReshapeFunctions/: riscv_reshape_s8_ref.c
  group NN/Source/SoftmaxFunctions
    ../../../NN/Tests/Ref/Source/SoftmaxFunctions/: riscv_softmax_q15_ref.c riscv_softmax_q7_ref.c riscv_softmax_s8_ref.c riscv_softmax_u8_ref.c riscv_softmax_with_batch_q7_ref.c
  group NN/Source/SVDFunctions
    ../../../NN/Tests/Ref/Source/SVDFunctions/: riscv_svdf_s8_ref.c
