<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\examples\riscv_bayes_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_class_marks_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_convolution_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_dotproduct_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_fft_bin_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_fir_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_graphic_equalizer_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_linear_interp_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_matrix_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_signal_converge_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_sin_cos_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_svm_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\examples\riscv_variance_example.ewp</path>
    </project>
    <batchBuild />
</workspace>
